# Keil uVision project COMM_TOOL_F103RET6.uvprojx, settings and files
target COMM_TOOL_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xFFE0) IROM(0x08008000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COMM_TOOL_Release
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\source;..\source\bsp;..\source\app;..\source\iap;..\vendor\STM32F10x_StdPeriph_Lib_V3.5.0\drivers;..\vendor\STM32F10x_StdPeriph_Lib_V3.5.0\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xffe0
  group App
    ../source/: main.c
    ../source/app/: ct_app.c ct_protocol.c ct_owc.c ct_modbus_bridge.c ct_crc16.c ct_debug_log.c ct_flash_store.c ct_can_gateway.c ct_upgrade_manager.c ct_boot_control.c ct_self_iap.c
  group BSP
    ../source/bsp/: board.c ct_watchdog.c board_uart.c board_owc.c board_can.c
    ../source/: stm32f10x_it.c
  group CMSIS
    ../vendor/STM32F10x_StdPeriph_Lib_V3.5.0/drivers/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
    ../source/: startup_default_handler.c
  group StdPeriph
    ../vendor/STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Headers
    ../source/app/: ct_board_port.h ct_config.h ct_debug_log.h ct_boot_control.h ct_self_iap.h ct_modbus_bridge.h
    ../source/: main.h stm32f10x_it.h
    ../source/bsp/: board.h ct_watchdog.h board_uart.h board_can.h
target COMM_TOOL_IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xFFE0) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COMM_TOOL_IAP
  c flags: as above
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xffe0
  group added to the first target's files
    ../source/iap/: ct_iap.c ct_iap.h ct_iap_main.c
  group left out of the first target's files
    ../source/app/: ct_app.c ct_board_port.h ct_boot_control.c ct_boot_control.h ct_can_gateway.c ct_crc16.c ct_debug_log.c ct_debug_log.h ct_flash_store.c ct_modbus_bridge.c ct_modbus_bridge.h ct_owc.c ct_protocol.c ct_self_iap.c ct_self_iap.h ct_upgrade_manager.c
    ../source/bsp/: board.c board.h board_can.c board_can.h board_owc.c board_uart.c board_uart.h
    ../source/: main.c main.h
